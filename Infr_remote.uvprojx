# Keil uVision project Infr_remote.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Infr_remote +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: .\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\mix;.\SYSTEM\sys;.\SYSTEM\usart;.\CORE;.\USER\inc;.\SYSTEM\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group usr
    ./USER/src/: main.c led.c key.c wifi_test.c ESP8266.c step_mote.c steering_engine.c io.c
  group sys
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/mix/: stm32f10x_it.c system_stm32f10x.c
    ./SYSTEM/timer/: timer.c
  group lib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group mix
    ./CORE/: core_cm3.c
  group start_up
    ./CORE/: startup_stm32f10x_hd.s
